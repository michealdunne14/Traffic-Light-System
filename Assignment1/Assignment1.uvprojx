# Keil uVision project Assignment1.uvprojx, settings and files
target XMC1100-Q024x0064 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: XMC1100-Q024x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.7.1
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Assignment1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.0.0, Device:XMClib:ACMP 2.1.16, Device:XMClib:BCCU 2.1.16, Device:XMClib:CAN 2.1.16, Device:XMClib:CCU4 2.1.16, Device:XMClib:CCU8 2.1.16, Device:XMClib:ERU 2.1.16, Device:XMClib:FLASH 2.1.16, Device:XMClib:GPIO 2.1.16, Device:XMClib:I2C 2.1.16, Device:XMClib:I2S 2.1.16, Device:XMClib:LEDTS 2.1.16, Device:XMClib:MATH 2.1.16, Device:XMClib:PAU 2.1.16, Device:XMClib:POSIF 2.1.16, Device:XMClib:PRNG 2.1.16, Device:XMClib:RTC 2.1.16, Device:XMClib:SCU 2.1.16, Device:XMClib:SPI 2.1.16, Device:XMClib:UART 2.1.16, Device:XMClib:VADC 2.1.16, Device:XMClib:WDT 2.1.16
